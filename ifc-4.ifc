Properties of the parts of a building model (IFC4)

# File
Description: Raumtemperaturregler mit Uhr, Heizen/Kühlen, UP, 230 VAC, Abdeckung 55 x 55 mm, reinweiß, matt, ViewDefinition[CoordinationView]
File name: ifc-4.ifc
Time: 2026-04-23T13:34:05+0000
Author: ALRE-IT Regeltechnik GmbH, mail@alre.de
Organization: ALRE-IT Regeltechnik GmbH, Richard-Tauber-Damm 10, 12277 Berlin, +49 30 39984-0, https://alre.de
Written by: 2.0.0
Made in: ALRE-IT BMEcat2IFC Exporter
Authorization: N/A

# IfcBuildingStorey, Geschoss
In: Gebaeude
Elevation: 0 m

# IfcBuildingElementProxy: UA220009, Raumtemperaturregler mit Uhr, Heizen/Kühlen, UP, 230 VAC, Abdeckung 55 x 55 mm, reinweiß, matt
In: Raum
Description: Unterputzregler zur zeitabhängigen Heiz-/Kühlregelung von 2- und 4-Rohrsystemen in Hotel-, Wohn- und Geschäftsräumen. Durch verschiedene Varianten in nahezu alle Flächenschalterprogramme adaptierbar. Es können bis zu 5 Ventilstellantriebe (stromlos offen oder geschlossen) je Ausgang angesteuert werden. im 2-Rohr-Betrieb kann die Betriebsart über einen externen Kontakt (Change-Over), Temperaturfühler oder im Menü umgeschaltet werden. Die Uhr kann als Master für andere Regler zur ECO-Umschaltung genutzt werden. Durch einen externen Kontakt kann die Energiesparfunktion (ECO) oder Frostschutz (STANDBY) aktiviert werden. Alternativ können die Eingänge des Reglers für einen externen Temperaturfühler (Wichtung zwischen internem und externem Fühler kann eingestellt werden) oder einen Taupunktsensor (TPS) konfiguriert werden. Über eine 0 … 10 V-Schnittstelle kann ein Ventilator (EC-Lüfter) drehzahlgeregelt werden.; Classification: EC011309 ETIM-Klasse (ETIM)
Pset_ManufacturerTypeInformation - Manufacturer: ALRE-IT Regeltechnik GmbH; ModelReference: UA220009; ModelLabel: KTRRUu217.456#56/V2; GlobalTradeItemNumber: 4050528066473; ProductURL: https://alre.de/produkt_UA220009
Pset_Specification - NominalLength: 0.071 m; NominalWidth: 0.071 m; NominalDepth: 0.046 m; NetWeight: 0.135
Pset_ALRE_ETIM_Properties - Farbe: weiß; Breite: 71; Höhe: 71; Tiefe: 46; RAL-Nummer: 9010; Anschluss: sonstige; Mit thermischer Rückführung: no; Art der Spannungsversorgung: 230 V; Kontaktausführung: Schließer (NO); Messbereich: 5; Bedienung: Taste; Explosionsgeschützt: no; Uhrentyp: Wochenuhr; Schutzart (IP): IP30; Ausführung Aufnehmer/Fühler: Widerstandssensor; Klasse des Temperaturreglers: IV; Schutzart (NEMA): sonstige; Max. Spannung der Kontakte: 230; Mit Empfänger: no; Regelcharakteristik: PI; Witterungsabhängige Regelung: no; Anzahl der Ausgänge Heizung: 1; Anzahl der Ausgänge Kühlung: 1; Ausführung Uhr: digital; Wahlschalter für Heizung und Warmwasser mit Heizung: no; Überstundenschalter: yes; Temperatur ablesbar: yes; Optimierung: yes; Anzahl der Schaltprogramme: 7; Max. Kontaktbelastung: 3; Differenzwert: 1; Sensor extern: no; Differenz verstellbar: no; Geeignet für Heizung: yes; Geeignet für Kühlen: yes; ETIM-Klasse: EC011309; ETIM-Version: ETIM-10.0
Pset_ALRE_Dokumente - Datenblatt: https://media.alre.de/deu_DEU/datasheet/ALRE_Datenblatt-UA220009.pdf
